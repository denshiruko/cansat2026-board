File: MCU/I2C-Sensors.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Update: コネクタをだいぶ消した
手配線になるね
